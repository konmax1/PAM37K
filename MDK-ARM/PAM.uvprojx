# Keil uVision project PAM.uvprojx, settings and files
target PAM (6090000::V6.9::.\ARMCLANG)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: PAM
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32L432xx,ARM_MATH_CM4,__DSP_PRESENT
  c include: ../Inc;                                                    ../Drivers/STM32L4xx_HAL_Driver/Inc;                                                    ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                                                    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                    ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                                                    ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Logic
    ../Src/: global.cpp psk.cpp worker.cpp
    ../Inc/: global.h psk.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L432KCUx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L432KCUx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:STM32Cube HAL:ADC 1.9.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:IWDG 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:RTC 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:Startup 1.3.1
